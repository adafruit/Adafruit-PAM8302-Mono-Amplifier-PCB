# Repository adafruit/Adafruit-PAM8302-Mono-Amplifier-PCB

File README.md:

## Adafruit PAM8302 Mono Amplifier PCB
<a href="http://www.adafruit.com/products/2130"><br/>
Click here to purchase one from the Adafruit shop</a>

This super small mono amplifier is surprisingly powerful - able to deliver up to 2.5 Watts into 4-8 ohm impedance speakers. Inside the miniature chip is a class D controller, able to run from 2.0V-5.5VDC. Since the amp is a class D, its very efficient (over 90% efficient when driving an 8Ω speaker at over half a Watt) - making it perfect for portable and battery-powered projects. It has built in thermal and over-current protection but we could barely tell it got hot. There's even a volume trim pot so you can adjust the volume on the board down from the default 24dB gain. This board is a welcome upgrade to basic "LM386" amps!

The A+ and A- inputs of the amplifier go through 1.0uF capacitors, so they are fully 'differential' - if you don't have differential outputs, simply tie the Audio- pin  to ground. The output is "Bridge Tied" - that means the output pins connect directly to the speaker pins, no connection to ground. The output is a high frequency 250KHz square wave PWM that is then 'averaged out' by the speaker coil - the high frequencies are not heard. All the above means that you can't connect the output into another amplifier, it should drive the speakers directly.

Comes with a fully assembled and tested breakout board. We also include header to plug it into a breadboard and a 3.5mm screw-terminal blocks so you can easily attach/detach your speaker.

These are the Eagle CAD files for the Adafruit PAM8302 Mono Amplifier

For more details, check out the product page at

-----> https://www.adafruit.com/products/2130

### License

Adafruit invests time and resources providing this open source design, please support Adafruit and open-source hardware by purchasing products from [Adafruit](https://www.adafruit.com)!

All text above must be included in any redistribution

Designed by Limor Fried/Ladyada for Adafruit Industries.
Creative Commons Attribution/Share-Alike, all text above must be included in any redistribution. 
See license.txt for additional information.

## EAGLE design Adafruit PAM8302.brd

Parts:
C1, C2: 1uF; 0805-NO
C3: 10uF; 0805-NO
C4, C5: 220pF; 0805-NO
FB1, FB2: Ferrite; _0805
FID1, FID2: FIDUCIAL""; FIDUCIAL_1MM
JP1: HEADER-1X570MIL; 1X05_ROUND_70
R1, R2: 100; 0805-NO
R3: 10K; 0805-NO
U1: PAM8302AASCR; MSOP8_0.65MM
U$10, U$11: MOUNTINGHOLE2.0; MOUNTINGHOLE_2.0_PLATED
VR1: 10K trim; TRIMPOT_BOURNS_3303W
X1: TERMBLOCK_1X2; TERMBLOCK_1X2-3.5MM

Connections:
AIN+: JP1.5, VR1.3 (E)
AIN-: C2.2, JP1.4, VR1.1 (A)
GND: C3.2, C4.2, C5.2, JP1.1, U1.7 (GND)
unnamed: R2.2, U1.4 (IN_N)
unnamed: R1.2, U1.3 (IN_P)
unnamed: C1.1, R1.1
unnamed: C2.1, R2.1
unnamed: FB2.1, U1.8 (VO_N)
unnamed: FB1.1, U1.5 (VO_P)
unnamed: C1.2, VR1.2 (S)
SD: JP1.3, R3.2, U1.1 (/SD)
VCC: C3.1, JP1.2, R3.1, U1.6 (VDD)
VO+: C5.1, FB1.2, X1.1
VO-: C4.1, FB2.2, X1.2

Notes on the sheet:
ToDo: Ferrite (select w/high Z at high F, low Z at low F). Try to block everything >1MHz or so.
C3: Use 1uF to filter high frequency noise, or 10uF if lower frequency noise is present
NOTE: For the best power on/off pop performance, the amplifier should be set in the shutdown mode prior to power on/off operation (set SD low to power down the amp).

Board: 2 copper layers, 24.1 x 15.2 mm, 22 parts (1 on the bottom side), 14 nets.

Other parts of the board:
U$3: SYMBOL_PLUS
U$4: SYMBOL_MINUS
U$5: ADAFRUIT_3.5MM
U$6: PCBFEAT-REV-040

## Commit log

2014-12-20 init!

Notices in the files:
parts and their libraries:
microbuilder: This work is placed in the public domain, and may be freely used for commercial and non-commercial work with the following conditions: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
